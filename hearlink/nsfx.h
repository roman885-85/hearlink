// Обработка звука «для слуха»: общий код передатчика, приёмника и проверки на компьютере (tools/host/nsfx.cpp).
//
//   NsSpec — спектральное шумозаглушение: убирает ровный шум («шипение») и во время звука, и в паузах.
//            Звук 32 кГц режется на перекрывающиеся окна по 8 мс (шаг 4 мс), у каждого окна считается спектр
//            (129 полос по 125 Гц); в каждой полосе помнится уровень шума, и полоса ослабляется тем сильнее, чем
//            ближе её уровень к шуму. Задержка — 6 мс. Быстрое преобразование Фурье на плате — из ESP-DSP.
//   NsDyn  — динамика усиления приёмника: сжатие вместо связки «усиление + ограничитель» и снятие усиления в паузах.
//
// Слова владельца 11.10.2026: «требуется активное шумоподавление, т.к. имеется сильный фоновый шум в виде шипения»,
// «при сильном усилении возникают завалы в звуке», «создать полный функционал с настройками и включением\отключением
// функций», «выполнить функции шумоподавления на передатчике и приемниках. Будем наблюдать где лучше будет работать».
#pragma once
#include <math.h>
#include <stdint.h>
#include <string.h>

#define NSX_N 256              // окно, отсчётов (8 мс)
#define NSX_H 128              // шаг (4 мс)
#define NSX_K (NSX_N / 2 + 1)  // полос
#define NSX_SR 32000.0f
#define NSX_MU 2000            // отрезок для поиска самого тихого места: 2000 шагов (8 с)
#define NSX_MW 75              // и сколько прошлых отрезков помнится: «тишина» — самое тихое за десять минут
#define NSX_DIRTY 125          // после цифровой тишины (разрыв звука) уровню не верим 125 шагов (0,5 с): плавный вход идёт 0,4 с

#define NSX_M (NSX_N / 2)      // длина комплексного преобразования: спектр вещественного окна в 256 отсчётов считается через него

// ---- быстрое преобразование Фурье на n комплексных чисел (d — пары «вещественная, мнимая»), n — 128
#ifdef ARDUINO
#include "esp_dsp.h"
static float nsxTab[NSX_N] __attribute__((aligned(16)));
static bool nsxTabOk;
static inline void nsxFft(float *d, int n) {
  if (!nsxTabOk) {
    dsps_fft2r_init_fc32(nsxTab, NSX_N);
    nsxTabOk = true;
  }
  dsps_fft2r_fc32(d, n);
  dsps_bit_rev2r_fc32(d, n);
}
#else
static inline void nsxFft(float *d, int n) {   // на компьютере — простое, по основанию 2
  for (int i = 1, j = 0; i < n; i++) {
    int bit = n >> 1;
    for (; j & bit; bit >>= 1) j ^= bit;
    j ^= bit;
    if (i < j) {
      float a = d[2 * i], b = d[2 * i + 1];
      d[2 * i] = d[2 * j];
      d[2 * i + 1] = d[2 * j + 1];
      d[2 * j] = a;
      d[2 * j + 1] = b;
    }
  }
  for (int len = 2; len <= n; len <<= 1)
    for (int i = 0; i < n; i += len)
      for (int k = 0; k < len / 2; k++) {
        float an = -2 * (float)M_PI * k / len, wr = cosf(an), wi = sinf(an);
        float *u = d + 2 * (i + k), *v = d + 2 * (i + k + len / 2);
        float tr = v[0] * wr - v[1] * wi, ti = v[0] * wi + v[1] * wr;
        v[0] = u[0] - tr;
        v[1] = u[1] - ti;
        u[0] += tr;
        u[1] += ti;
      }
}
#endif
// окно (половина синусоиды: при перекрытии наполовину квадраты окон в сумме дают единицу) и повороты для перехода
// между комплексным преобразованием на 128 и спектром вещественных 256 отсчётов — общие, считаются один раз
static float nsxWin[NSX_N], nsxCos[NSX_M + 1], nsxSin[NSX_M + 1];
static bool nsxTablesOk;
static inline void nsxTables() {
  if (nsxTablesOk) return;
  for (int i = 0; i < NSX_N; i++) nsxWin[i] = sinf((float)M_PI * (i + 0.5f) / NSX_N);
  for (int k = 0; k <= NSX_M; k++) {
    nsxCos[k] = cosf(2 * (float)M_PI * k / NSX_N);
    nsxSin[k] = sinf(2 * (float)M_PI * k / NSX_N);
  }
  nsxTablesOk = true;
}

// Сила шумозаглушения: 0 — выключено; 1 — слабое (до −8 дБ), 2 — среднее (до −14 дБ), 3 — сильное (до −20 дБ).
// Чем сильнее, тем заметнее могут быть следы обработки («водянистый» остаток шума, чуть глуше тихие окончания).
// Грубый двоичный логарифм (ошибка до 0,09): показатель числа и его мантисса «по прямой». Нужен 53 раза на шаг —
// библиотечная функция тут слишком дорога.
static inline float nsxLog2(float x) {
  union {
    float f;
    uint32_t u;
  } v = { x };
  return (float)((int)(v.u >> 23) - 127) + (float)(v.u & 0x7FFFFF) * (1.0f / 8388608.0f);
}

// Точные и быстрые двоичный логарифм и степень двойки — для сжатия (NsDyn, с 3.00). Библиотечные log10f и powf
// звались там до четырёх раз на каждые 8 отсчётов, и «чёткость и сжатие» у приёмника брали 100–125 мкс из каждой
// миллисекунды (замер Y15 15.10). Логарифм — показатель числа плюс логарифм мантиссы рядом atanh (ошибка ~1e-7, то
// есть меньше миллионной доли децибела), степень — целая часть в показатель, дробная — многочленом (ошибка ~3e-6).
static inline float nsxLog2a(float x) {   // x > 0
  union {
    float f;
    uint32_t u;
  } v = { x };
  int e = (int)(v.u >> 23) - 127;
  v.u = (v.u & 0x7FFFFF) | 0x3F800000;   // мантисса 1…2
  float m = v.f;
  if (m > 1.41421356f) {
    m *= 0.5f;
    e++;
  }
  float t = (m - 1) / (m + 1), t2 = t * t;
  return (float)e + 2.88539008f * t * (1 + t2 * (0.333333333f + t2 * (0.2f + t2 * 0.142857143f)));   // 2/ln2 · atanh(t)
}
static inline float nsxExp2a(float y) {   // 2^y
  if (y < -125) return 0;
  if (y > 125) y = 125;
  int i = (int)(y + 0.5f);
  if ((float)i > y + 0.5f) i--;          // округление вниз и для отрицательных
  float f = (y - (float)i) * 0.693147181f;   // −0,35…0,35
  float p = 1 + f * (1 + f * (0.5f + f * (0.166666667f + f * (0.0416666667f + f * (0.00833333333f + f * 0.00138888889f)))));
  union {
    float f;
    uint32_t u;
  } v = { p };
  v.u += (uint32_t)i << 23;
  return v.f;
}

// Шаг шумозаглушения на плате собирается с O2 (с 3.01; вся прошивка — -Os). Как у свёртки подгонки темпа (rsdot.h):
// в -Os суммы и временные чаще живут в стеке, а не в регистрах. В быструю память (IRAM) не переносится: у передатчика
// её нет (внутренней свободно 41 КБ при правиле «не меньше 40»).
#ifdef ARDUINO
#define NSX_HOT __attribute__((optimize("O2")))
#else
#define NSX_HOT
#endif

struct NsSpec {
  // --- настройки (менять можно на ходу)
  uint8_t level = 0;
  uint8_t sens = 2;                // чувствительность 0…4: во сколько раз оценку шума считать больше измеренной (1 / 1,4 / 1,9 / 2,6 / 3,4).
                                   // Выше — шум убирается полнее, но тихие окончания слов глуше; ниже — осторожнее
  bool frozen = false;             // оценку шума не обновлять: держится запомненная (learnStart) или последняя
  // --- состояние
  float inM[NSX_N];                // последние 256 отсчётов середины
  float olM[NSX_H], outM[NSX_H];   // хвост прошлого окна (сложится с началом следующего) и готовые отсчёты
  float inS[NSX_N];                // разность каналов (с 2.89 — своим спектром, с теми же усилениями полос, что у середины)
  float olS[NSX_H], outS[NSX_H];
  float Nz[NSX_K], Gp[NSX_K], gp[NSX_K], G[NSX_K], acc[NSX_K], pw[NSX_K], Xr[NSX_K], Xi[NSX_K];
  float tmpM[NSX_H], tmpS[NSX_H];
  float totS, fCur, fWin[NSX_MW];   // общая мощность (сглаженная) и её наименьшее: в текущем отрезке и в прошлых
  float tCur, tWin[NSX_MW];         // и наибольшее — там же: пауза должна быть намного тише самого громкого (с 2.76)
  int fill, outLeft, learnLeft, learnN, fCount, fPos, pauseRun;
  int dirty;                       // сколько шагов ещё не верить уровню: только что была цифровая тишина (разрыв звука)
  bool primed, haveNoise;           // haveNoise — спектр шума уже известен
  uint32_t hops, pauseHops;         // pauseHops — для отчёта: сколько шагов сочтено паузой (по ним учится шум)
  float redDb;                      // для отчёта: на сколько в среднем сейчас убавлено, дБ (по мощности)

  void reset() {
    nsxTables();
    memset(inM, 0, sizeof(inM));
    memset(olM, 0, sizeof(olM));
    memset(outM, 0, sizeof(outM));
    memset(inS, 0, sizeof(inS));
    memset(olS, 0, sizeof(olS));
    memset(outS, 0, sizeof(outS));
    for (int k = 0; k < NSX_K; k++) {
      Nz[k] = 0;
      Gp[k] = 1;
      gp[k] = 1;
      G[k] = 1;
      acc[k] = 0;
    }
    for (int w = 0; w < NSX_MW; w++) {
      fWin[w] = 1e30f;
      tWin[w] = 0;
    }
    totS = 0;
    fCur = 1e30f;
    tCur = 0;
    fill = outLeft = learnLeft = learnN = fCount = fPos = pauseRun = 0;
    dirty = NSX_DIRTY;
    primed = haveNoise = false;
    hops = pauseHops = 0;
    redDb = 0;
    // «Образец шума запомнен» снимается вместе с самим образцом (Nz обнулён выше). До 2.75 признак здесь не
    // трогался, а память под NsSpec берётся malloc — без конструктора, то есть «= false» в описании поля не
    // срабатывало: после перезапуска программой (каждое обновление по радио) в поле оказывался мусор, приёмник
    // считал образец «запомненным», шуму не учился и ничего не убирал («зразок шуму запам'ятовано», «кроків у
    // паузах 0», «прибирає 0.0 дБ») — пока оператор не выбирал «сам». Замечено 12.10 на обоих приёмниках.
    frozen = false;
  }
  // «Запомнить шум сейчас»: секунду копится средний спектр (в эфире должна быть только тишина с шумом), потом он
  // держится неизменным, пока не попросят снова или не вернут «сам» (frozen = false).
  void learnStart() {
    for (int k = 0; k < NSX_K; k++) acc[k] = 0;
    learnN = 0;
    learnLeft = 250;
  }

  // один шаг: в inM лежат 256 отсчётов, на выходе — 128 готовых в outM. z — память под 256 чисел (выровненная).
  // спектр окна in (256 отсчётов) → Xr, Xi (129 полос)
  NSX_HOT void analyse(const float *in, float *z) {
    for (int n = 0; n < NSX_M; n++) {
      z[2 * n] = in[2 * n] * nsxWin[2 * n];
      z[2 * n + 1] = in[2 * n + 1] * nsxWin[2 * n + 1];
    }
    nsxFft(z, NSX_M);
    for (int k = 0; k <= NSX_M; k++) {
      int a = k & (NSX_M - 1), b = (NSX_M - k) & (NSX_M - 1);
      float ar = z[2 * a], ai = z[2 * a + 1], br = z[2 * b], bi = -z[2 * b + 1];
      float er = 0.5f * (ar + br), ei = 0.5f * (ai + bi), orr = 0.5f * (ai - bi), oi = -0.5f * (ar - br);
      Xr[k] = er + nsxCos[k] * orr + nsxSin[k] * oi;
      Xi[k] = ei + nsxCos[k] * oi - nsxSin[k] * orr;
    }
  }
  // обратно: спектр Xr, Xi с усилениями G → комплексное преобразование на 128 (обратное — прямым, через сопряжение) →
  // окно → 128 готовых отсчётов в out (вместе с хвостом прошлого окна ol), новый хвост — в ol
  NSX_HOT void synth(float *z, float *out, float *ol) {
    for (int k = 0; k < NSX_M; k++) {
      int m = NSX_M - k;
      float ar = Xr[k] * G[k], ai = Xi[k] * G[k], br = Xr[m] * G[m], bi = -Xi[m] * G[m];
      float er = 0.5f * (ar + br), ei = 0.5f * (ai + bi), dr = 0.5f * (ar - br), di = 0.5f * (ai - bi);
      float orr = dr * nsxCos[k] - di * nsxSin[k], oi = dr * nsxSin[k] + di * nsxCos[k];
      z[2 * k] = er - oi;            // Z = E + jO, сразу сопряжённое
      z[2 * k + 1] = -(ei + orr);
    }
    nsxFft(z, NSX_M);
    const float sc = 1.0f / NSX_M;
    for (int n = 0; n < NSX_M; n++) {   // после сопряжения: чётные отсчёты — вещественная часть, нечётные — мнимая со знаком
      float e = z[2 * n] * sc, o = -z[2 * n + 1] * sc;
      int i0 = 2 * n, i1 = 2 * n + 1;
      float y0 = e * nsxWin[i0], y1 = o * nsxWin[i1];
      if (i0 < NSX_H) {
        out[i0] = ol[i0] + y0;
        out[i1] = ol[i1] + y1;
      } else {
        ol[i0 - NSX_H] = y0;
        ol[i1 - NSX_H] = y1;
      }
    }
  }

  NSX_HOT void hop(float *z, bool stereo) {
    static const float FLOOR[4] = { 1.0f, 0.398f, 0.200f, 0.100f }, OVER[5] = { 1.0f, 1.4f, 1.9f, 2.6f, 3.4f };
    float gFloor = FLOOR[level > 3 ? 0 : level], over = OVER[sens > 4 ? 2 : sens];
    // спектр окна: чётные отсчёты — в вещественную часть, нечётные — в мнимую; преобразование на 128; разбор на 129 полос
    for (int n = 0; n < NSX_M; n++) {
      z[2 * n] = inM[2 * n] * nsxWin[2 * n];
      z[2 * n + 1] = inM[2 * n + 1] * nsxWin[2 * n + 1];
    }
    nsxFft(z, NSX_M);
    float tot = 0;
    for (int k = 0; k <= NSX_M; k++) {
      int a = k & (NSX_M - 1), b = (NSX_M - k) & (NSX_M - 1);
      float ar = z[2 * a], ai = z[2 * a + 1], br = z[2 * b], bi = -z[2 * b + 1];
      float er = 0.5f * (ar + br), ei = 0.5f * (ai + bi), orr = 0.5f * (ai - bi), oi = -0.5f * (ar - br);
      float xr = er + nsxCos[k] * orr + nsxSin[k] * oi, xi = ei + nsxCos[k] * oi - nsxSin[k] * orr;
      Xr[k] = xr;
      Xi[k] = xi;
      pw[k] = xr * xr + xi * xi;
      if (k >= 2) tot += pw[k];   // без самого низа: там постоянная составляющая и гул
    }
    totS = hops ? 0.8f * totS + 0.2f * tot : tot;
    hops++;
    // Разрыв звука (запас приёмника кончился, передатчик молчал, приёмник спал): на входе цифровая тишина, потом
    // звук плавно входит. Сглаженный уровень в это время проходит через все значения ниже настоящего шума; до 2.76
    // одно из них становилось «самым тихим за десять минут», и пауз после этого шумозаглушение не находило вовсе —
    // на приборе «кроків у паузах 0» держалось, пока разрывы шли чаще, чем раз в десять минут (то есть при слабом
    // сигнале — всегда). А вход на паузе ещё и занижал запомненный шум. Теперь полсекунды после тишины не в счёт.
    if (tot < 30.0f) dirty = NSX_DIRTY;
    else if (dirty) dirty--;
    if (learnLeft) {   // копим средний спектр шума
      for (int k = 0; k < NSX_K; k++) acc[k] += pw[k];
      learnN++;
      if (--learnLeft == 0) {
        for (int k = 0; k < NSX_K; k++) {
          float a = acc[k], n = 1;   // чуть сгладить по частоте: у оценки за секунду ещё заметный разброс
          if (k > 0) {
            a += acc[k - 1];
            n++;
          }
          if (k < NSX_K - 1) {
            a += acc[k + 1];
            n++;
          }
          Nz[k] = a / (n * learnN);
        }
        haveNoise = true;
        frozen = true;
      }
    } else if (!frozen && totS > 30.0f && !dirty) {   // (тише −90 дБ — это не шум входа, а цифровая тишина: по ней не учимся)
      // Шум запоминается в паузах и только в них. Пауза — когда общая мощность звука не больше чем втрое (4,8 дБ)
      // выше самого тихого, что было за последние десять минут, и держится так десятую секунды. В паузе спектр шума
      // усредняется: вниз — за ~0,2 с, вверх — за ~20 с (тихое место музыки, принятое за паузу, оценку почти не
      // поднимет, а шум, который вправду вырос, запомнится за минуту пауз). Пока идёт звук — речь или сплошная
      // музыка — оценка не трогается вовсе.
      // Первая проба (11.10) оценивала шум на ходу, по наименьшей мощности каждой полосы за три секунды: на речи это
      // работало, а сплошную музыку принимало за шум и глушило — «музыка к шуму» из 29,9 дБ делалась 23–27 дБ.
      // Шум вырос (прибавили усиление источника) — пауз «по-старому» не станет, и оценка обновится, когда прежнее
      // «самое тихое» выйдет из памяти: до тех пор шум просто убирается слабее, зато звук не глушится.
      if (totS < fCur) fCur = totS;
      if (totS > tCur) tCur = totS;
      if (++fCount >= NSX_MU) {
        fWin[fPos] = fCur;
        tWin[fPos] = tCur;
        fPos = fPos + 1 == NSX_MW ? 0 : fPos + 1;
        fCount = 0;
        fCur = totS;
        tCur = totS;
      }
      float quiet = fCur, top = tCur;
      for (int w = 0; w < NSX_MW; w++) {
        if (fWin[w] < quiet) quiet = fWin[w];
        if (tWin[w] > top) top = tWin[w];
      }
      // И ещё условие (с 2.76): «самое тихое» должно быть хотя бы на 15 дБ тише самого громкого за те же десять
      // минут. Пока приёмник слышал один уровень (только что включён, сплошная музыка), «самое тихое» — это просто
      // сам звук, и принимать его за паузу нельзя. До 2.76 от этого спасала случайность: плавный вход звука после
      // тишины оставлял заниженное «самое тихое» (см. dirty выше).
      bool low = totS < 3.0f * quiet && top > 31.6f * quiet && hops > 250;   // первую секунду только слушаем
      // И третье (с 2.76): в паузе спектр «ровный» — шум. Тихое место музыки или гласная на спаде — это гармоники,
      // пики над провалами, и за шум их принимать нельзя: до 2.76 музыку с тихими местами от этого спасал только
      // заниженный уровень «самого тихого» после разрыва звука (см. dirty) — а когда его не было, шумозаглушение
      // запоминало музыку как шум и глушило её (проверка на компьютере: уровень музыки −5,7 дБ).
      // Мера — на сколько среднее логарифмов мощности полос 0,5–7 кГц ниже логарифма средней мощности: у шума
      // (белого — 0,83, «розового» — 1,3) меньше 2,7 двоичных порядков, у музыки и речи — 3…8.
      if (low) {
        float sl = 0, sm = 0;
        for (int k = 4; k <= 56; k++) {
          sl += nsxLog2(pw[k] + 1e-3f);
          sm += pw[k];
        }
        low = sl * (1.0f / 53) - nsxLog2(sm * (1.0f / 53) + 1e-3f) > -2.7f;
      }
      pauseRun = low ? pauseRun + 1 : 0;
      if (pauseRun >= 25) {
        pauseHops++;
        float a = haveNoise ? 0.02f : 0.2f;   // первое знакомство с шумом — быстрее
        for (int k = 0; k < NSX_K; k++) {
          float v = pw[k], n = 1;   // по трём соседним полосам: шипение ровное по частоте
          if (k > 0) {
            v += pw[k - 1];
            n++;
          }
          if (k < NSX_K - 1) {
            v += pw[k + 1];
            n++;
          }
          v /= n;
          Nz[k] = haveNoise || pauseRun > 25 ? Nz[k] + (v - Nz[k]) * (haveNoise && v > Nz[k] ? 0.0002f : a) : v;
        }
        if (pauseRun >= 40) haveNoise = true;
      }
    }
    // усиление полос: решающая обратная связь (Эфраим — Мала) с правилом Винера — без «звенящего» остатка
    for (int k = 0; k < NSX_K; k++) {
      float n = over * Nz[k] + 1e-3f;
      float gamma = pw[k] / n, xi = 0.96f * Gp[k] * Gp[k] * gp[k] + 0.04f * (gamma > 1 ? gamma - 1 : 0);
      float g = haveNoise ? xi / (1 + xi) : 1.0f;
      if (g < gFloor) g = gFloor;
      Gp[k] = g;
      gp[k] = gamma;
    }
    float red = 0;
    tot = 0;
    for (int k = 0; k < NSX_K; k++) {   // лёгкое сглаживание по частоте
      float a = Gp[k > 0 ? k - 1 : k], c = Gp[k < NSX_K - 1 ? k + 1 : k];
      G[k] = level ? 0.25f * a + 0.5f * Gp[k] + 0.25f * c : 1.0f;
      red += pw[k] * G[k] * G[k];
      tot += pw[k];
    }
    float ratio = tot > 1 ? (red + 1e-3f) / tot : 1;
    redDb = 3.01029996f * nsxLog2a(ratio);   // 10·lg (с 3.01 — без библиотечного log10f)
    synth(z, outM, olM);
    // Разность каналов — со своим спектром и с ТЕМИ ЖЕ усилениями полос (с 2.89). До 2.89 она лишь ждала столько же и
    // ослаблялась одним общим числом — тем, что вышло у середины в целом. Когда середина в одних полосах ослаблена, а
    // разность нет, Л = С + Р и П = С − Р перестают быть «левым и правым»: звук, сведённый в один канал, протекал во
    // второй (−16…−20 дБ к себе — тихая музыка только в Л на уровне шума, tools/host/nsstereo.cpp) и слабел в своём.
    // Владелец 14.10 (2.88): «при включении шумодава появляются щелчки» и «пропадает один канал при шумодаве».
    // Теперь Л и П получают одинаковую обработку. Цена — ещё два преобразования на шаг (только в стерео).
    if (stereo) {
      analyse(inS, z);
      synth(z, outS, olS);
    }
  }

  // Кадр на месте: n отсчётов (128 должно делиться на n: 32, 64, 128), m — середина, s — разность каналов.
  // work — память под 256 чисел, выровненная на 16 байт. Выход отстаёт от входа на 256 − n отсчётов:
  // при n = 64 (передатчик) — на 6 мс, при n = 32 (приёмник) — на 7 мс. В стерео разность идёт тем же путём, что
  // середина, с теми же усилениями полос (см. конец hop).
  NSX_HOT void runF(float *m, float *s, int n, bool stereo, float *work) {
    for (int i = 0; i < n; i++) {
      inM[NSX_H + fill + i] = m[i];
      inS[NSX_H + fill + i] = stereo ? s[i] : 0;
    }
    fill += n;
    if (fill >= NSX_H) {
      hop(work, stereo);
      memmove(inM, inM + NSX_H, NSX_H * sizeof(float));
      memmove(inS, inS + NSX_H, NSX_H * sizeof(float));
      fill = 0;
      outLeft = NSX_H;
      primed = true;
    }
    int from = NSX_H - outLeft;
    bool have = primed && outLeft > 0;
    for (int i = 0; i < n; i++) {
      m[i] = have ? outM[from + i] : 0;
      if (stereo) s[i] = have ? outS[from + i] : 0;
    }
    if (outLeft > 0) outLeft -= n;
  }
  void run(int16_t *m, int16_t *s, int n, bool stereo, float *work) {
    for (int i = 0; i < n; i++) {
      tmpM[i] = m[i];
      tmpS[i] = stereo ? s[i] : 0;
    }
    runF(tmpM, tmpS, n, stereo, work);
    for (int i = 0; i < n; i++) {
      float a = tmpM[i], b = tmpS[i];
      m[i] = (int16_t)(a > 32767 ? 32767 : a < -32768 ? -32768 : lrintf(a));
      if (stereo) s[i] = (int16_t)(b > 32767 ? 32767 : b < -32768 ? -32768 : lrintf(b));
    }
  }
};

// ---- Динамика усиления приёмника
// До 2.68 усиление было простым множителем, а всё, что после него не помещалось в шкалу, держал ограничитель: он
// опускает усиление по одному пику и возвращает четверть секунды. При усилении +16…+24 дБ пики идут сплошь — после
// каждого громкого слога звук «проваливался» и медленно возвращался (владелец 11.10: «при сильном усилении возникают
// завалы в звуке»; замер на компьютере: через 20 мс после громкого тихое получало +8,8 дБ вместо +20, через 120 мс —
// +14), а в паузах на те же +20 дБ поднимался шум входа.
// Теперь усиление целиком достаётся тихому, а по мере приближения к краю шкалы плавно убавляется («сжатие»): выше
// «колена» уровень растёт в R раз медленнее, а за край шкалы не выходит вовсе. Усиление следует за огибающей звука и
// возвращается за десятки миллисекунд: пик держится 8 мс (период самого низкого голоса — усиление не «дышит» внутри
// периода), потом огибающая спадает на 8,7 дБ за каждые 18 мс. Прежнему ограничителю остаются только выбросы в
// первые полторы миллисекунды.
//   сжатие 1 «легке»   — колено −3 дБ от края шкалы, 4:1: громкость почти как у прежней связки, но без провалов;
//   сжатие 2 «середнє» — колено −8 дБ, 3:1;
//   сжатие 3 «сильне»  — колено −14 дБ, 2,5:1: громкое выходит заметно тише тихого — ровнее, спокойнее для долгого
//                        слушания.
// «В паузах»: приёмник помнит уровень, ниже которого звук не опускается (шум источника), и когда звук лишь немного
// выше него — усиление снимается (и, по настройке, звук ещё приглушается на 6 или 12 дБ).
struct NsDyn {
  // --- настройки
  float boostDb = 0;     // усиление, дБ (0…24)
  uint8_t comp = 1;      // сжатие: 0 — нет (как до 2.68), 1 — лёгкое, 2 — среднее, 3 — сильное
  uint8_t gate = 0;      // в паузах: 0 — ничего, 1 — усиление снять, 2 — и ещё −6 дБ, 3 — и ещё −12 дБ
  uint8_t gateThr = 1;   // порог паузы 0…4: звук считается паузой, пока он не выше шума на 3 / 6 / 9 / 12 / 15 дБ
  uint8_t gateRel = 1;   // как быстро пауза «закрывается»: 0 — быстро (60 мс), 1 — средне (150 мс), 2 — медленно (400 мс)
  // --- состояние
  float env = 0, envIn = 0, gRed = 1, gGate = 1, tRed = 1, tGate = 1, floorDb = -50;
  int tick = 0, hold = 0, envHold = 0;
  float redLowDb = 0;    // для отчёта: наибольшее убавление сжатием, дБ (обнуляет читающий)
  float gateLowDb = 0;   // и приглушением в паузах

  // aOut — величина отсчёта после громкости, до усиления (больший из каналов); aIn — величина середины до громкости;
  // boostLin — усиление множителем (уже сглаженное). Возвращает множитель, на который надо домножить вдобавок к нему.
  // Множитель прикладывается к звуку ПОСЛЕ задержки ограничителя (1,5 мс): сжатие видит пик раньше, чем он дойдёт
  // до выхода, и успевает убавить; ограничитель же смотрит на то, каким отсчёт станет после сжатия (цель — tRed), и
  // не трогает то, с чем сжатие справится само.
  inline float run(float aOut, float aIn, float boostLin) {
    if (aOut >= env) {
      env = aOut;
      envHold = 256;
    } else if (envHold) envHold--;
    else env *= 0.998266f;
    envIn += (aIn - envIn) * (aIn > envIn ? 0.0031f : 0.000625f);   // средняя величина: вверх за 10 мс, вниз за 50 мс
    if (++tick >= 8) {   // пересчёт цели раз в четверть миллисекунды (логарифмы — nsxLog2a/nsxExp2a, с 3.00)
      tick = 0;
      if (comp && boostDb > 0.5f) {
        static const float KNEE[4] = { 0, -3, -8, -14 }, SLOPE[4] = { 0, 0.75f, 0.6667f, 0.6f };   // SLOPE = 1 − 1/R
        uint8_t c = comp > 3 ? 3 : comp;
        float d = 6.02059991f * nsxLog2a(env * boostLin * (1.0f / 32768) + 1e-9f), over = d - KNEE[c], red;   // 20·lg
        if (over <= -3) red = 0;
        else if (over < 3) red = (over + 3) * (over + 3) * (1.0f / 12) * SLOPE[c];   // мягкое колено ±3 дБ
        else red = over * SLOPE[c];
        if (d - red > -1.5f) red = d + 1.5f;   // потолок — на полтора децибела ниже края шкалы: ограничителю почти нечего делать
        tRed = nsxExp2a(-red * 0.166096405f);   // 10^(−red/20)
        if (red > redLowDb) redLowDb = red;
      } else tRed = 1;
      if (gate) {
        float lin = 6.02059991f * nsxLog2a(envIn * (1.0f / 32768) + 1e-9f);
        if (lin < floorDb) floorDb += (lin - floorDb) * 0.02f;   // дно шума: вниз быстро,
        else floorDb += 0.0000625f;                               // вверх — на четверть децибела в секунду,
        if (floorDb > -38) floorDb = -38;                         // и не выше −38 дБ: громче — уже не шум, а звук
        if (floorDb < -90) floorDb = -90;
        float x = (lin - (floorDb + 3.0f + 3.0f * (gateThr > 4 ? 1 : gateThr))) * 0.1f;   // 0 — у порога над шумом, 1 — на 10 дБ выше порога
        x = x < 0 ? 0 : x > 1 ? 1 : x;
        if (x >= 1) hold = 480;                                   // после звука 120 мс не закрываемся: окончания слов
        else if (hold) {
          hold--;
          x = 1;
        }
        float depth = (boostDb + (gate == 2 ? 6 : gate == 3 ? 12 : 0)) * (1 - x);
        tGate = nsxExp2a(-depth * 0.166096405f);
        if (depth > gateLowDb) gateLowDb = depth;
      } else tGate = 1;
    }
    gRed += (tRed - gRed) * (tRed < gRed ? 0.0606f : 0.00208f);        // убавить — за 0,5 мс, вернуть — за 15 мс
    static const float CLOSE[3] = { 0.000521f, 0.000208f, 0.0000781f };
    gGate += (tGate - gGate) * (tGate > gGate ? 0.0104f : CLOSE[gateRel > 2 ? 1 : gateRel]);   // открыть — за 3 мс, закрыть — по настройке
    return gRed * gGate;
  }
};
