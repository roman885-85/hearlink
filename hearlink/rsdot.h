// Подгонка темпа приёмника (rxaudio.h): один отсчёт выхода — середина и, в стерео, разность каналов. Свёртка taps
// отсчётов кольца с коэффициентами строки таблицы c0, подправленными на долю a к следующей строке (c0 + taps).
// Общая для прибора и проверки на компьютере (tools/host/rsdot.cpp).
//
// Отдельной небольшой функцией с O2 — с 2.97. До того свёртка шла прямо в rxTask (9 КБ кода, собранного -Os), и
// сумма середины жила в стеке: на каждый отвод — чтение и запись памяти и два перехода, ~45 тактов. Подгонка темпа
// брала 270–290 мкс из каждой миллисекунды (замер Y15 15.10), а весь тракт — 830–910 мкс: задаче звука доставалось
// 83–93 % второго ядра. Здесь у каждой свёртки по две частичные суммы (умножения не ждут друг друга), подправленный
// коэффициент сразу идёт в обе свёртки. Порядок сложения другой — результат расходится с
// прежним на единицы младшего разряда float (проверка: tools/host/rsdot.cpp).
// Первая проба 2.97 (коэффициенты отдельным проходом в массив, потом две свёртки) на приборе — 1209 тактов на вызов
// при «тёплом» кэше (Y16): каждый шаг того прохода ждал предыдущий (загрузка → вычитание → умножение → запись).
#pragma once
#include <stdint.h>

#ifndef RS_HOT
#ifdef ARDUINO
#define RS_HOT __attribute__((optimize("O2")))
#else
#define RS_HOT
#endif
#endif

enum { RS_TAPS_MAX = 48 };   // taps — кратно четырём, не больше этого

// Отсчёты — int16 (обычные качества) или int32 (с 23.10: «Монітор», 24 бита в кольце).
template <typename T>
static RS_HOT void rsDotT(const float *c0, float a, int taps, const T *xm, const T *xs, float *ym, float *ys) {
  const float *c1 = c0 + taps;
  if (!xs) {   // моно: одна свёртка
    float m0 = 0, m1 = 0, m2 = 0, m3 = 0;
    for (int j = 0; j < taps; j += 4) {
      m0 += (c0[j] + (c1[j] - c0[j]) * a) * xm[j];
      m1 += (c0[j + 1] + (c1[j + 1] - c0[j + 1]) * a) * xm[j + 1];
      m2 += (c0[j + 2] + (c1[j + 2] - c0[j + 2]) * a) * xm[j + 2];
      m3 += (c0[j + 3] + (c1[j + 3] - c0[j + 3]) * a) * xm[j + 3];
    }
    *ym = (m0 + m1) + (m2 + m3);
    return;
  }
  // по два отвода за шаг: четыре суммы, два коэффициента и временные — в 16 регистрах с плавающей точкой без выгрузки
  // в стек (с четырьмя отводами за шаг их не хватало)
  float m0 = 0, m1 = 0, s0 = 0, s1 = 0;
  for (int j = 0; j < taps; j += 2) {   // коэффициент подправляется один раз и идёт в обе свёртки
    float k0 = c0[j] + (c1[j] - c0[j]) * a, k1 = c0[j + 1] + (c1[j + 1] - c0[j + 1]) * a;
    m0 += k0 * xm[j];
    s0 += k0 * xs[j];
    m1 += k1 * xm[j + 1];
    s1 += k1 * xs[j + 1];
  }
  *ym = m0 + m1;
  *ys = s0 + s1;
}
static inline void rsDot(const float *c0, float a, int taps, const int16_t *xm, const int16_t *xs, float *ym, float *ys) {
  rsDotT<int16_t>(c0, a, taps, xm, xs, ym, ys);
}
