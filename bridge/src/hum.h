// Гул радіо передавача на аналоговому вході моста — віднімання за шаблоном (з 23.10).
// Імпульси струму радіо передавача (пакет раз на 2 мс, чередування — період 4 мс) просочуються в аналоговий вхід PCM1808:
// у тиші лінія 250 Гц −81 дБ з непарними гармоніками (750, 1250 Гц), на 15 дБ сильніше, ніж коли модуль стояв прямо на
// передавачі (16.10: −96…−98). Передача зупинена (`z1`) — лінія падає до −118 дБ: це саме радіо. Залізом (дроселі,
// конденсатори, окреме живлення) у власника не прибралось.
// Гул іде в такт пакетам, а пакети — в такт кадрам передавача, тобто й кадрам виходу моста (вихід веде такт передавача):
// після перерахунку частоти гул повторюється рівно через 128 кадрів (32 кГц; замір 22.10: період 127,99–128,00).
// Тож його форма вчиться усередненням по циклу (16 мс — покриває періоди 4, 8 і 16 мс) і віднімається.
// Музика в шаблон не потрапляє: кожен цикл вчить з вагою E0 / (E0 + E), де E — середня енергія залишку цього циклу, E0 —
// рівень −76 дБ: тиша з гулом (−81…−86 дБ) — вага ~0,8…0,9, музика −40 дБ — 0,0003 (і менше — множник 1/64 стає нулем).
// Вчиться цикл, уже записаний повністю (з вагою за весь цикл), — на наступному проході тієї самої позиції; удар звуку
// посеред циклу не встигає зіпсувати шаблон. Перевірено на Mac на записах 22.10 (bridge/test/hum_test.c): тиша → музика
// (+12 дБ, як аналог) → тиша — лінія 250 Гц −81 → −105 дБ, 750 Гц −102 → −118, 1250 Гц −108 → −121, і під час музики теж.
// Решта гулу — нерівна (гребінка через 20,8 Гц: службові пакети, повтори) — у шаблон не лягає, лишається −85 дБ сумарно.
// Шаблон стирається при зміні входу, частоти виходу, перерахунку з початку і збої такту виходу: зсувається фаза.
#pragma once
#include <stdbool.h>
#include <stdint.h>
#include <string.h>

#ifndef HUM_FN
#define HUM_FN(f) f
#endif

#define HUM_MAX 768             // відліків у циклі найбільше: 16 мс при 48 кГц
#define HUM_E0 6889u            // −76 дБ у одиницях енергії залишку: (2^23 · 10^(−76/20) / 16)^2
typedef struct {
  int32_t t[HUM_MAX][2];        // шаблон гулу, Q8 (24 біти · 256)
  int32_t b[HUM_MAX][2];        // відліки минулого циклу (обмежені ±2^21) — для навчання з вагою того циклу
  uint64_t e;                   // енергія залишку за нинішній цикл: Σ (y >> 4)^2
  uint32_t k, p;                // позиція в циклі; довжина циклу, кадрів виходу
  uint32_t w;                   // вага навчання для b, 0…64 (64 — повна)
  uint32_t s;                   // крок навчання 2^−s: 2 на початку (швидко), до 6 (точно) — за кількістю тихих циклів n
  uint32_t n;                   // тихих циклів, з яких шаблон уже вчився (до 64)
  uint32_t eLast;               // середня енергія залишку останнього циклу (для рядка стану)
  bool prev;                    // b записано повністю — є чим вчитися
} hum_t;

static inline void hum_reset(hum_t *h, uint32_t fsOut) {
  memset(h->t, 0, sizeof h->t);
  h->p = fsOut / 1000u * 16u;
  if (h->p > HUM_MAX) h->p = HUM_MAX;
  h->k = 0;
  h->e = 0;
  h->w = 0;
  h->s = 2;
  h->n = 0;
  h->eLast = 0;
  h->prev = false;
}

// Один кадр виходу (24 біти зі знаком): навчання на відліку минулого циклу в цій самій позиції, віднімання шаблону.
// Усе в 32 бітах (на RP2040 немає 64-бітного множення): |b| ≤ 2^21 → (b << 8) − t ≤ 2^30; (d >> 6) · w ≤ 2^30.
static inline void HUM_FN(hum_step)(hum_t *h, int32_t *l, int32_t *r) {
  uint32_t k = h->k;
  int32_t *t = h->t[k], *b = h->b[k];
  int32_t x[2] = { *l, *r };
  for (int c = 0; c < 2; c++) {
    int32_t tc = t[c];
    if (h->prev && h->w) {
      int32_t d = (b[c] << 8) - tc;
      tc += ((d >> 6) * (int32_t)h->w) >> h->s;   // крок 2^−s · вага w/64
      t[c] = tc;
    }
    int32_t xc = x[c];
    b[c] = xc > (1 << 21) ? (1 << 21) : xc < -(1 << 21) ? -(1 << 21) : xc;
    int32_t y = xc - ((tc + 128) >> 8);
    x[c] = y;
    int32_t q = y >> 4;
    q = q > 32767 ? 32767 : q < -32767 ? -32767 : q;
    h->e += (uint32_t)(q * q);
  }
  *l = x[0];
  *r = x[1];
  if (++k >= h->p) {   // цикл записано: його вага — для навчання на наступному проході
    k = 0;
    if (h->prev && h->w >= 32 && h->n < 64) h->n++;   // щойно пройдений прохід учився з тихого циклу
    h->s = h->n < 4 ? 2 : h->n < 8 ? 3 : h->n < 16 ? 4 : h->n < 32 ? 5 : 6;   // ~ середнє за n циклів, далі — за 64
    uint32_t em = (uint32_t)(h->e / (2u * h->p));
    h->eLast = em;
    h->w = (uint32_t)(((uint64_t)HUM_E0 * 64u) / ((uint64_t)HUM_E0 + em));
    h->prev = true;
    h->e = 0;
  }
  h->k = k;
}

// Рівень шаблону (СКВ, у частках повної шкали 24 біт) — для рядка стану; рахує ядро 0, гонка з ядром 1 тут не страшна.
static inline float hum_level(const hum_t *h) {
  float s = 0;
  for (uint32_t i = 0; i < h->p; i++) {
    float a = (float)h->t[i][0] * (1.0f / 2147483648.0f), c = (float)h->t[i][1] * (1.0f / 2147483648.0f);
    s += a * a + c * c;   // Q8 від 24 біт = частки 2^31
  }
  return h->p ? s / (2.0f * (float)h->p) : 0.0f;
}
